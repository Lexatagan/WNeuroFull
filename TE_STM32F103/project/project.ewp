# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; VECT_TAB_FLASH; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32_USB-FS-Device_Lib_V4.0.0\inc; ..\..\TMetLib\inc; ..\..\DBGLib\inc; ..\..\LANLib\inc; ..\..\nRFTransceiver\inc; ..\..\UARTTransceiver\inc; ..\..\USBTransceiver\inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application Files
    ../source/: Functions.c hw_config.c main.c stm32f10x_it.c
  group DBGLib
    ../../DBGLib/src/: DBG.c
  group LANLib
    ../../LANLib/src/: LAN.c
  group nRFTransceiver
    ../../nRFTransceiver/src/: hal_nrf_l01.c hal_nrf_stm32_hw.c NRF24Tranciever.c
  group STM32F10X/CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
    ../source/: system_stm32f10x.c
  group STM32F10X/STM32F10X_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group TMetLib
    ../../TMetLib/src/: TimeMeter.c
  group UARTTransceiver
    ../../UARTTransceiver/src/: UARTTransceiver.c
  group USB-FS-Device_Driver
    ../../Libraries/STM32_USB-FS-Device_Lib_V4.0.0/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBTransceiver
    ../../USBTransceiver/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
