# IAR project Project.ewp, settings and files
configuration HY_STM32MINI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_HY_STM32MINI; LAN_DEVICE; nADEBUG
  ICCARM.CCIncludePath2: ..\include; ..\USBLib\library\inc; ..\FWLib\library\inc; ..\TMetLib\library\inc; ..\LCDLib\library\inc; ..\LANLib\library\inc; ..\nRFLib\library\inc; ..\DBGLib\library\inc; ..\Functions\inc; ..\UARTLib\library\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VirtualCOMPort.srec
  ILINK.IlinkOutputFile: Result.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NK_STM32F103 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STDPERIPH_DRIVER; USE_NK_STM32F103; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\include; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32_USB-FS-Device_Lib_V4.0.0\inc; ..\TMetLib\library\inc; ..\LCDLib\library\inc; ..\PCCommLib\library\inc; ..\LANLib\library\inc; ..\nRFLib\library\inc; ..\DBGLib\library\inc; ..\Functions\inc; ..\UARTTransceiver\library\inc; ..\USBTransceiver\inc
configuration TE_STM32F103 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STDPERIPH_DRIVER; USE_TE_STM32F103; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\include; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32_USB-FS-Device_Lib_V4.0.0\inc; ..\TMetLib\library\inc; ..\LCDLib\library\inc; ..\LANLib\library\inc; ..\nRFLib\library\inc; ..\DBGLib\library\inc; ..\Functions\inc; ..\UARTTransceiver\library\inc
configuration SWITCHER_1.0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_SWTCH10; LAN_DEVICE
  group Application Files
    ../source/: hw_config.c main.c stm32f10x_it.c
  group DBG
    ../DBGLib/library/src/: DBG.c
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group Functions
    ../Functions/src/: Functions.c
  group STM32F10X/STM32_USB-FS-Device_Lib
    ../Libraries/STM32_USB-FS-Device_Lib_V4.0.0/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10X/STM32F10X_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group LANLib
    ../LANLib/library/src/: LAN.c
  group LCDLib
    ../LCDLib/library/src/: fonts.c LCD.c ssd1289.c
  group nRFLib
    ../nRFLib/library/src/: hal_nrf_l01.c hal_nrf_stm32_hw.c NRF24Tranciever.c
  group TMetLib
    ../TMetLib/library/src/: TimeMeter.c
  group UARTTransceiver
    ../UARTTransceiver/library/src/: UARTTransceiver.c
  group USBTransceiver
    ../USBTransceiver/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
